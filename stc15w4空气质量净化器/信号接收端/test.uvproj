# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: delay.c main.c Timer.c uart.c key.c DHT11.c LCD1602.c oled.c 15AD.c
